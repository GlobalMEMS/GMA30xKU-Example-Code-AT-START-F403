# Keil uVision project GMA30xKU.uvprojx, settings and files
target GMA30xKU (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: AT32F403ZC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_HD,LIBRARY_VERSION
  c include: ..;..\LibGMEMS;..\LibGMEMS\GMA30xKU;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\HyperTerminal_Interrupt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_hd.s
  group AT32Periph
    ../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c at32f4xx_i2c.c at32f4xx_dbgmcu.c
  group README
    ../: readme.txt
  group LibGMEMS
    ../LibGMEMS/: i2c_gmems.c bus_support.c gSensor_autoNil.c
    ../LibGMEMS/GMA30xKU/: gma30xku.c
